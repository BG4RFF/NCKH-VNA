# Keil uVision project VNA_TM4C1294XL.uvprojx, settings and files
target VNA_TM4C1294XL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VNA_TM4C1294XL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;.\Src\User\Inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Library
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
  group User
    ./Src/User/Src/: main.c Button_Control.c UART_Driver.c ADC_Driver.c Led.c SPI_Driver.c LCD5110.c delay.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
