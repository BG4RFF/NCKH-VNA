# Keil uVision project VNA_TM4C1294XL.uvprojx, settings and files
target VNA_TM4C1294XL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VNA_TM4C1294XL
  AfterMake: fromelf --bin --output .\Objects\VNA_TM4C1294XL.bin .\Objects\VNA_TM4C1294XL.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;.\Src\User\Inc;C:\ti\TivaWare_C_Series-2.1.4.178\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Objects\VNA_TM4C1294XL.sct
  link misc: --entry Reset_Handler
  group Library
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
  group User
    ./Src/User/Src/: main.c UART_Driver.c Led.c delay.c jsmn.c JSONObject.c HC05_Driver.c ADC_Driver.c nrf.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
