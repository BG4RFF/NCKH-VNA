# Keil uVision project VNA_STM32F103C8T6.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VNA_STM32F103C8T6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\SourceCode\CMSIS\CoreSupport;.\SourceCode\CMSIS\DeviceSupport\ST\STM32F10x;.\SourceCode\User\Inc;.\SourceCode\StdPeriph;.\SourceCode\StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./SourceCode/Startup/: startup_stm32f10x_md.s
  group User
    ./SourceCode/User/Src/: main.c Button_Control.c
  group CMSIS
    ./SourceCode/CMSIS/CoreSupport/: core_cm3.c
    ./SourceCode/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph
    ./SourceCode/StdPeriph/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c
