# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\CMSIS\CoreSupport;.\src\CMSIS\DeviceSupport\ST\STM32F10x;.\src\StdPeriph\inc;.\src\User\inc;.\src\StdPeriph
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./src/CMSIS/CoreSupport/: core_cm3.c
    ./src/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./src/Startup/: startup_stm32f10x_md.s
  group StdPeriph
    ./src/StdPeriph/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group User
    ./: main.c
    ./src/User/src/: cJSON.c cJSON_Utils.c UART_Driver.c
