# Keil uVision project adf4351_drv.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: adf4351_drv
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __USE_C99_MATH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c adf4351.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
